# Keil uVision project lces.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lces +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Library
  group CPU
    ../User/CPU/: STARTUP.A51 cpu.h iap15w4k58s4.h stc15f2k60s2.h
  group APP
    ../User/APP/: app.c app.h cfg.h
    ../User/: all.h
  group DRIVER
    ../User/DRIVER/: driver.h driDelay.c driDelay.h driGpio.c driGpio.h driLcd12864.c driLcd12864.h
  group INTERRUPT
    ../User/INTERRUPT/: interrupt.h itrUart.c itrUart.h
  group OS
    ../User/OS/: os.h pt-plus.h pt.h pt-os.c pt-sem.h lc.h lc-switch.h lc-addrlabels.h
